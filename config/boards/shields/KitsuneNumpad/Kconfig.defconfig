## config/boards/shields/KitsuneNumpad/Kconfig.defconfig
```kconfig
if SHIELD_KITSUNENUMPAD

config ZMK_KEYBOARD_NAME
    default "KitsuneNumpad"

endif
```
